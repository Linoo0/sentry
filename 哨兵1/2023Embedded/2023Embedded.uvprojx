# Keil uVision project 2023Embedded.uvprojx, settings and files
target 2023Embedded (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 2022Embedded +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT
  c misc: --diag_suppress=223
  c include: .\libraries\inc;.\drivers;.\startup;.\bsp;.\drivers\hardware\can;.\drivers\hardware\usart;.\drivers\hardware\tim;.\drivers\hardware\rc;.\drivers\gyro;.\drivers\app\pid;.\drivers\app\can_receive;.\drivers\app\chassis_control;.\drivers\app\holder_control;.\drivers\referee;.\drivers\hardware\crc;.\drivers\app\rifle;.\drivers\visual\visual communication;.\drivers\referee
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./startup/: startup_stm32f4xx.s
    ./drivers/: main.c
  group stm32f4x
    ./libraries/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c system_stm32f4xx.c
  group hardware
    ./drivers/hardware/can/: can.c can.h
    ./drivers/hardware/usart/: usart.c usart.h
    ./drivers/hardware/tim/: tim.c tim.h
    ./drivers/hardware/rc/: rc.c rc.h
    ./drivers/hardware/crc/: crc.c crc.h
  group app
    ./drivers/app/pid/: pid.c pid.h pid_config.c pid_config.h
    ./drivers/app/can_receive/: can_receive.c can_receive.h
    ./drivers/app/chassis_control/: chassis_control.c chassis_control.h
    ./drivers/app/holder_control/: holder_control.c holder_control.h
    ./drivers/app/rifle/: rifle.c rifle.h
  group gyro
    ./drivers/gyro/: imu_data_decode.c imu_data_decode.h packet.c packet.h
  group referee
    ./drivers/referee/: referee.c referee.h robot_interaction.c robot_interaction.h
  group visual
    ./drivers/visual/visual communication/: visual communication.c visual communication.h
