# Keil uVision project sentry.uvprojx, settings and files
target sentry (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: sentry +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../bsp;../gyro;../bsp/can_receive;../bsp/pid;..\bsp\chassis_control;..\bsp\holder_control;..\bsp\rifle;..\visual\visual communication;..\bsp\crc8_crc16;..\referee
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group bsp
    ../bsp/: bsp_rc.c bsp_rc.h vofa.c vofa.h
    ../bsp/can_receive/: can_receive.c can_receive.h
    ../bsp/pid/: pid.c pid.h pid_config.c pid_config.h
    ../bsp/chassis_control/: chassis_control.c chassis_control.h
    ../bsp/holder_control/: holder_control.c holder_control.h
    ../bsp/rifle/: rifle.c rifle.h
    ../bsp/crc8_crc16/: crc8_crc16.c crc8_crc16.h
  group gyro
    ../gyro/: imu_data_decode.c imu_data_decode.h packet.c packet.h
  group visual
    ../visual/visual communication/: visual communication.c visual communication.h
  group referee
    ../referee/: referee.c referee.h
software components: CMSIS:CORE 4.3.0
